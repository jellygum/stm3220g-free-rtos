# Keil uVision project Project.uvproj, settings and files
target STM322xG_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\Libraries\STM32F20x_StdPeriph_Driver\Inc;..\..\..\..\..\Utilities\STM32_EVAL\STM3220G_EVAL;..\..\..\..\..\Libraries\BSP\Components\cs43l22;..\..\..\..\..\Utilities\Fonts;..\..\..\..\..\Libraries\BSP\Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Libraries/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Libraries/BSP/Components/ili9320/: ili9320.c
    ../../../../../Libraries/BSP/Components/ili9325/: ili9325.c
    ../../../../../Libraries/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3220G_EVAL/: stm322xg_eval.c stm322xg_eval_audio.c stm322xg_eval_io.c stm322xg_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../Libraries/STM32F20x_StdPeriph_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c
  group Example/MDK-ARM
    ./: startup_stm32f217xx.s
  group Example/User
    ../Src/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
